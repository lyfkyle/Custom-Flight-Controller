# IAR project FlightControllerV2.ewp, settings and files
configuration FlightControllerV2 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: FlightControllerV2.hex
  ILINK.IlinkOutputFile: FlightControllerV2.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
    ../Inc/: UAV_Defines.h
  group Application/User/app/main_app
    ../Src/apps/main_app/: main_app.cpp
    ../Inc/: main_app.h
  group Application/User/app/test_app
    ../Src/apps/test_app/: test_app.cpp
    ../Inc/: test_app.h
  group Application/User/drivers/I2C
    ../Src/drivers/I2C/: i2c.c
    ../Inc/: i2c.h
  group Application/User/drivers/LED
    ../Src/drivers/LED/: led.c
    ../Inc/: led.h
  group Application/User/drivers/MPU9250
    ../Src/drivers/MPU9250/: MPU9250.cpp
    ../Inc/: MPU9250.h MPU9250_def.h
  group Application/User/drivers/MPU9250_DMP
    ../Src/drivers/MPU9250_DMP/util/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../Inc/: inv_mpu.h inv_mpu_dmp_motion_driver.h MPU9250_RegisterMap.h
    ../Src/drivers/MPU9250_DMP/: SparkFunMPU9250-DMP.cpp
  group Application/User/drivers/PWM
    ../Src/drivers/PWM/: pwm.c
    ../Inc/: pwm.h
  group Application/User/drivers/SBUS
    ../Src/drivers/SBUS/: sbus.c
    ../Inc/: sbus.h
  group Application/User/drivers/UART
    ../Src/drivers/UART/: uart.c
    ../Inc/: uart.h
  group Application/User/HAL/IMU
    ../Src/HAL/IMU/: IMU.cpp
    ../Inc/: IMU.h
  group Application/User/HAL/receiver
    ../Src/HAL/Receiver/: receiver.cpp
    ../Inc/: receiver.h
  group Application/User/libraries/logging
    ../Src/libraries/logging/: logging.c
    ../Inc/: logging.h
  group Application/User/libraries/MadgwickAHRS
    ../Src/libraries/MadgwickAHRS/: MadgwickAHRS.cpp
    ../Inc/: MadgwickAHRS.h
  group Application/User/libraries/PID
    ../Src/libraries/PID/: PID.cpp
    ../Inc/: PID.h
  group Application/User/libraries/ping_pong_buffer
    ../Src/libraries/ping_pong_buffer/: ping_pong_buffer.c
    ../Inc/: ping_pong_buffer.h
  group Application/User/libraries/QKF
    ../Src/libraries/QKF/: QKF.cpp
    ../Inc/: QKF.h
  group Application/User/libraries/ring_buffer
    ../Src/libraries/ring_buffer/: ring_buffer.c
    ../Inc/: ring_buffer.h
  group Application/User/libraries/util
    ../Src/libraries/util/: util.cpp
    ../Inc/: util.h
  group Application/User/services/cmd_listener_service
    ../Src/services/cmd_listener_service/: cmd_listener.cpp
    ../Inc/: cmd_listener.h
  group Application/User/services/controller_service
    ../Src/services/controller_service/: controller.cpp controller_att.cpp controller_att_rate.cpp controller_util.cpp controller_vel.cpp
    ../Inc/: controller.h controller_att.h controller_att_rate.h controller_util.h controller_vel.h
  group Application/User/services/device_ctrl_service
    ../Src/services/device_ctrl_service/: device_ctrl.cpp
    ../Inc/: device_ctrl.h
  group Application/User/services/motor_ctrl_service
    ../Src/services/motor_ctrl_service/: motor_ctrl.cpp
    ../Inc/: motor_ctrl.h
  group Application/User/services/sensor_reader_service
    ../Src/services/sensor_reader_service/: sensor_reader.cpp
    ../Inc/: sensor_reader.h
  group Application/User/services/state_estimation_service
    ../Src/services/state_estimation_service/: state_estimator.cpp
    ../Inc/: state_estimator.h
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
