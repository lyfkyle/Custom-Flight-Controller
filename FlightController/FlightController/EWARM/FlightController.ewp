# IAR project FlightController.ewp, settings and files
configuration FlightController (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: FlightController.srec
  ILINK.IlinkOutputFile: FlightController.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f429xx.s
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
    ../Inc/: stm32f4xx_hal_conf.h
  group Application/User/Defines
    ../Inc/: UAV_Defines.h
  group Application/User/Driver/I2C
    ../Src/Driver/I2C/: i2c.c
    ../Inc/: i2c.h
  group Application/User/Driver/MPU9250
    ../Src/Driver/MPU9250/: MPU9250.cpp
    ../Inc/: MPU9250.h MPU9250_def.h
  group Application/User/Driver/PWM
    ../Src/Driver/PWM/: pwm.c
    ../Inc/: pwm.h
  group Application/User/Driver/SBUS
    ../Src/Driver/SBUS/: sbus.c
    ../Inc/: sbus.h
  group Application/User/Driver/UART
    ../Src/Driver/UART/: uart.c
    ../Inc/: uart.h
  group Application/User/Platform/HAL/IMU
    ../Src/Platform/HAL/IMU/: IMU.cpp
    ../Inc/: IMU.h
  group Application/User/Platform/HAL/Logging
    ../Src/Platform/Lib/Logging/: logging.cpp
    ../Inc/: logging.h
  group Application/User/Platform/Lib/MadgwickAHRS
    ../Src/Platform/Lib/MadgwickAHRS/: MadgwickAHRS.cpp
    ../Inc/: MadgwickAHRS.h
  group Application/User/Platform/Lib/PID
    ../Src/Platform/Lib/PID/: PID.cpp
    ../Inc/: PID.h
  group Application/User/Platform/Lib/PingPongBuffer
    ../Src/Platform/Lib/PingPongBuffer/: ping_pong_buffer.c
    ../Inc/: ping_pong_buffer.h
  group Application/User/Platform/Lib/QKF
    ../Src/Platform/Lib/QKF/: QKF.cpp
    ../Inc/: QKF.h
  group Application/User/Platform/Lib/Ringbuffer
    ../Src/Platform/Lib/Ringbuffer/: ringbuf.c
    ../Inc/: ringbuf.h
  group Application/User/Product/App
    ../Src/Product/App/TestApp/: TestIMU.cpp
    ../Inc/: TestIMU.h
  group Application/User/Product/App/MainApp
    ../Src/Product/App/MainApp/: main_app.cpp
    ../Inc/: main_app.h
  group Application/User/Product/CmdListener
    ../Src/Product/CmdListener/: cmd_listener.cpp
    ../Inc/: cmd_listener.h
  group Application/User/Product/Component/DeviceCtrl
    ../Src/Product/Component/DeviceCtrl/: DeviceCtrl.cpp
    ../Inc/: DeviceCtrl.h
  group Application/User/Product/Component/InterruptMgr
    ../Src/Product/Component/InterruptMgr/: interrupt_mgr.cpp
    ../Inc/: interrupt_mgr.h
  group Application/User/Product/Controller
    ../Src/Product/Controller/: controller.cpp controller_att.cpp controller_att_rate.cpp controller_util.cpp controller_vel.cpp motor_ctrl.cpp
    ../Inc/: controller.h controller_att.h controller_att_rate.h controller_util.h controller_vel.h motor_ctrl.h
  group Application/User/Product/SensorReader
    ../Src/Product/SensorReader/: sensor_reader.cpp
    ../Inc/: sensor_reader.h
  group Application/User/Product/StateEstimator
    ../Src/Product/StateEstimator/: state_estimator.cpp
    ../Inc/: state_estimator.h
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
